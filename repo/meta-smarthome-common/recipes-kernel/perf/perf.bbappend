PR="r10"

PACKAGECONFIG += "dwarf"
RDEPENDS:${PN}-doc:remove = "man"
