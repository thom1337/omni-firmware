ALTERNATIVE:${PN} += "pager"
ALTERNATIVE_LINK_NAME[pager] = "${bindir}/pager"
ALTERNATIVE_TARGET[pager]  = "${bindir}/less.less"
