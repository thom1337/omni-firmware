FILESEXTRAPATHS:prepend := "${THISDIR}/time:"

PR = "1"

SRC_URI += "file://0001-Force-wait3-syscall.patch"
