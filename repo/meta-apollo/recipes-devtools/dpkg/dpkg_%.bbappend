RDEPENDS:${PN} += "diffutils gzip tar"
