PACKAGECONFIG:remove = "readline"
