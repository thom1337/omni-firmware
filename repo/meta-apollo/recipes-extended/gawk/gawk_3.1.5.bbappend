FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

PR = "r1"

SRC_URI += "file://0001-remove-invalid-free-call.patch"