FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

PR = "r1"

SRC_URI += "file://0001-Add-avastmark-and-connavastmark-support.patch"

