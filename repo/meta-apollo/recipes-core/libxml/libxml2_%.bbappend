EXTRA_OECONF = "--without-legacy --with-catalog --without-docbook --with-c14n --without-lzma --with-fexceptions"
