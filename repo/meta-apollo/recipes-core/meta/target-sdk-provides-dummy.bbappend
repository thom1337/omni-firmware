# TODO: thd in newer versin having some issue with sdk package
# once we will update yocto we should remove this
DUMMYPROVIDES = " "
