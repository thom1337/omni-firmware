RDEPENDS_${PN}_remove = "nativesdk-qemu"
RDEPENDS_${PN}_remove = "nativesdk-qemu-helper"
RDEPENDS_${PN}_remove = "nativesdk-meson"
