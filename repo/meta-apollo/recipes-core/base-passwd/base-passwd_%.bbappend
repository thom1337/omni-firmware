FILESEXTRAPATHS_prepend := "${THISDIR}/base-passwd:"

SRC_URI += "file://0002-replace-sh-with-zsh-for-root.patch"
