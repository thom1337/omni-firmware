FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

PR = "2"

SRC_URI += "file://0001-Add-avastmark-support.patch"
